# Keil uVision project TINY_AC_SOURCE_F302.uvprojx, settings and files
target TINY_AC_SOURCE_F302 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F302RBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TINY_AC_SOURCE_F302 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F302xC,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=8000000,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\Drivers\CMSIS\DSP\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ./: startup_stm32f302xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f3xx_it.c GM_adc.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_adc.c stm32f3xx_ll_dma.c stm32f3xx_ll_rcc.c stm32f3xx_ll_comp.c stm32f3xx_ll_dac.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
